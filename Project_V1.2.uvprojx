# Keil uVision project Project_V1.2.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project_V1.2
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c include: .\Common;.\PortDriver\HeaderFiles;.\NVICDriver\HeaderFiles;.\GPTDriver\HeaderFiles;.\DIODriver\HeaderFiles
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ./: main.c App.h App.c
  group Configurations
    ./DIODriver/Config/: Dio_Lcfg.c Dio_PBcfg.c
    ./GPTDriver/Config/: Gpt_Lcfg.c
    ./NVICDriver/Config/: NVIC_Lcfg.c
    ./PortDriver/Config/: Port_Lcfg.c Port_PBcfg.c
  group Header_Files
    ./Common/: Common_Macros.h Compiler.h Det.h Std_Types.h TM4C123GH6PM_Hw.h
    ./DIODriver/HeaderFiles/: Dio.h Dio_Cfg.h Dio_Types.h
    ./GPTDriver/HeaderFiles/: Gpt.h Gpt_cfg.h Gpt_Types.h
    ./NVICDriver/HeaderFiles/: NVIC.h NVIC_Cfg.h NVIC_Types.h
    ./PortDriver/HeaderFiles/: Port.h Port_Cfg.h Port_Types.h
    ./: Led.h Button.h
  group ProgramFiles
    ./Common/: Det.c
    ./DIODriver/Program/: Dio.c
    ./GPTDriver/Program/: Gpt.c
    ./NVICDriver/Program/: NVIC_Prog.c
    ./PortDriver/Program/: Port.c
software components: CMSIS:CORE 5.5.0, Compiler:Event Recorder 1.4.0, Device:Startup 1.0.1
